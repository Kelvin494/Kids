# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/include/: list.h portmacro.h FreeRTOSConfig.h FreeRTOS.h task.h projdefs.h
    ../freertos/: list.c task.c
    ../freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
